# IAR project Backup of watchdog.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x40
  General.SCCStackSize: 0x128
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.newCCIncludePaths: common_files; $PROJ_DIR$
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm32.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  ICCAVR.CCDefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\lnk0t.xcl
  XLINK.XExtraOptions: -y(CODE); -Ointel-extended,(DATA)=$EXE_DIR$\$PROJ_FNAME$_data.hex; -Ointel-extended,(XDATA)=$EXE_DIR$\$PROJ_FNAME$_eeprom.hex
  group (top)
    ./: checkstatesignals.c checkstatesignals.h command.c command.h configpin.c configpin.h delay.c delay.h events.c events.h i2c_eeprom.c i2c_eeprom.h menu.c menu.h OWIBitFunctions.h OWIHighLevelFunctions.c OWIHighLevelFunctions.h OWIPolled.h OWISWBitFunctions.c TerminalDemo.c TerminalDriver.c TerminalDriver.h timer.c timer.h types.h uart_addon.c uart_addon.h usart.c usart.h vars.c vars.h
    common_files/: OWIcrc.c OWIcrc.h OWIdefs.h OWIDeviceSpecific.h
